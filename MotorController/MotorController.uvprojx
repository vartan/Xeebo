# Keil uVision project MotorController.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC11U24FBD64/401 NXP
  pack: Keil.LPC1100_DFP.1.3.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) IRAM2(0x20004000,0x0800) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: MotorController
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  memory RVCT10: RAM 0x20004000 size 0x800
  group Source Group 1
    ./: main.c message_handler.c message_queue.c MotorDriver.c timers.c uart.c globals.h main.h message_handler.h message_queue.h MotorDriver.h timers.h uart.h
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
